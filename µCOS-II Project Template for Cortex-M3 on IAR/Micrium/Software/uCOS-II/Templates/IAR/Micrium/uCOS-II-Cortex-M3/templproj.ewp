# IAR project templproj.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: $PROJ_DIR$; $_MICRIUM_$\Micrium\Software\uC-CPU; $_MICRIUM_$\Micrium\Software\uC-CPU\ARM-Cortex-M3\IAR; $_MICRIUM_$\Micrium\Software\uC-LIB; $_MICRIUM_$\Micrium\Software\uCOS-II\Source; $_MICRIUM_$\Micrium\Software\uCOS-II\Ports\ARM-Cortex-M3\Generic\IAR
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: $FILE_BNAME$.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group App
    ./: app.c app_cfg.h app_hooks.c cpu_cfg.h includes.h lib_cfg.h os_cfg.h
  group uC/CPU
    $_MICRIUM_$/Micrium/Software/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
  group uC/CPU/ARM-Cortex-M3
    $_MICRIUM_$/Micrium/Software/uC-CPU/ARM-Cortex-M3/IAR/: cpu.h cpu_a.asm cpu_c.c
  group uC/LIB
    $_MICRIUM_$/Micrium/Software/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group uC/LIB/Ports/ARM-Cortex-M3
    $_MICRIUM_$/Micrium/Software/uC-LIB/Ports/ARM-Cortex-M3/IAR/: lib_mem_a.asm
  group uC/OS-II/Ports/ARM-Cortex-M3
    $_MICRIUM_$/Micrium/Software/uCOS-II/Ports/ARM-Cortex-M3/Generic/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group uC/OS-II/Source
    $_MICRIUM_$/Micrium/Software/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
